# Keil uVision project tsi_try.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: tsi_try
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Group 1
    ./: TouchCapacitiv.c TouchCapacitiv.h main.c Pwm.c Pwm.h Uart.c Uart.h
    ../../tsi/: ClockSettings.c ClockSettings.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.5.0
